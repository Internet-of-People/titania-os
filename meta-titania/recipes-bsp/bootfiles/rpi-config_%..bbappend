# Enable UART by default
# TODO: is there a security consideration against that?
ENABLE_UART="1"