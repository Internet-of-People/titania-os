require natpmp.inc

