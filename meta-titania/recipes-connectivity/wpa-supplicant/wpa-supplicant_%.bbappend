# OpenSSL is more stable than GnuTLS
# TODO: find an embedded alternative if needed (#19)
PACKAGECONFIG="openssl"