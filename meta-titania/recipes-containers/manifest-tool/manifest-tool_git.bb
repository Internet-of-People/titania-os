require manifest-tool.inc

SRCREV = "d34bbcbd34189b6fe671479d03479fe2e05b2be0"