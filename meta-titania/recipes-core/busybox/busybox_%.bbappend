FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
SRC_URI += "file://0001-rw-location-for-passwd-busybox.patch"
