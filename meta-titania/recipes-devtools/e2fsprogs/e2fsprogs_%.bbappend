FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
SRC_URI += "file://0001-name-clash-with-glibc2.27.patch"