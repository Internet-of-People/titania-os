inherit setuptools
require python-djangorestframework.inc