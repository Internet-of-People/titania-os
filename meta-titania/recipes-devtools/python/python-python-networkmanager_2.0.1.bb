inherit setuptools
require python-networkmanager.inc