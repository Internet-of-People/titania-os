include recipes-devtools/python/python-django_1.10.5.bb
inherit setuptools3