require python-fusepy.inc
inherit setuptools3