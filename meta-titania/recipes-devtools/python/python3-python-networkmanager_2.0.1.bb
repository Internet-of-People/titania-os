require python-networkmanager.inc
inherit setuptools3