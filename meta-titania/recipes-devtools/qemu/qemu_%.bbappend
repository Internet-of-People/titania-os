FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
SRC_URI += "file://0001-glibc-2.27-memfd.patch"