require dapp-systemd-bridge.inc

SRCREV = "2990c8f3c14e0a3f06f68909abdf9305d4aeb8f4"
