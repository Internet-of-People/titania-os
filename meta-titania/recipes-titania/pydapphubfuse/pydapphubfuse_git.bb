require pydapphubfuse.inc

SRCREV = "f5bb694bee91e8596aa1732441a00a060500b24d"
