require ux-titania.inc

SRCREV = "8aa94170ca8efc36f14b10d7a0f0f04b0d5cc511"
UX_BRANCH = "develop"