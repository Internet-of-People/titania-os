require vuedj.inc

SRCREV = "2ec4385756f664b3792dae3cb88e574dd4fb29a9"